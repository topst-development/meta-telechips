FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
#TODO:Sometimes a geoclue build error has occurred and will be corrected later.
#PACKAGECONFIG:append = "geoclue"
