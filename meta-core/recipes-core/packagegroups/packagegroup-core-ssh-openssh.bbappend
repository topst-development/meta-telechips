RDEPENDS:${PN} += "openssh-sftp-server rsync"
