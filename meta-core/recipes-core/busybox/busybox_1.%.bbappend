FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://truncate.cfg"

