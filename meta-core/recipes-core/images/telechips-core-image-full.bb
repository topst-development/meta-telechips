#
# Copyright (C) Telechips Inc.
#

require telechips-core-image-minimal.bb

IMAGE_INSTALL += " \
    packagegroup-telechips-core-graphics \
	packagegroup-telechips-core-multimedia \
"

