#
# Copyright (C) Telechips Inc.
#

require telechips-core-image-minimal.bb

IMAGE_INSTALL += " \
	packagegroup-telechips-core-multimedia \
"

