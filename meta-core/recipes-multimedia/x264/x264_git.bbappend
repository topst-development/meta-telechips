X264_DISABLE_ASM:armv7a = "--disable-asm"
