PACKAGECONFIG:remove = "sdl virglrenderer epoxy"
