RDEPENDS:${PN} += "packagegroup-core-sdk packagegroup-core-standalone-sdk-target"
RDEPENDS:${PN} += "p7zip yasm nasm flex popt libaio"
